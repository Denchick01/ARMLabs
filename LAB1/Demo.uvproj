# Keil uVision project Demo.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR32F9Q1I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Demo +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: text.c Font_6x8.c Font_7x10_bold.c Font_7x10_thin.c Font_12x16.c gl.c joystick.c lcd.c leds.c Main.c Menu.c Menu_gl.c Menu_leds.c Menu_text.c systick.c startup_MPS.s analog.c uart.c test.c timer.c FlashDev.c FlashPrg.c
