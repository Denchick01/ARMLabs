# Keil uVision project 1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MDR32F9Q1I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1
  c flags: Optim=1
  c include: ..\Milandr2;.\CMSIS;.\int
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: 1986be91_adc.h 1986be91_bkp.h 1986be91_can.h 1986be91_comp.h 1986be91_dac.h 1986be91_dma.h 1986be91_eeprom.h 1986be91_ext_bus_cntrl.h 1986be91_i2c.h 1986be91_iwdg.h 1986be91_port.h 1986be91_power.h 1986be91_rst_clk.h 1986be91_spi.h 1986be91_sys.h 1986be91_timer.h 1986be91_uart.h 1986be91_usb.h 1986be91_wwdg.h 1986be91t1.h main.c cm3_macro.h MDR32Fx.h system_MDR32F9Qx.c system_MDR32F9Qx.h startup_MDR32F9Qx.s MDR32F9Qx_board.h MDR32F9Qx_config.h MDR32F9Qx_lib.h
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stdint.h
  group int
    ./int/: MDR32F9Qx_board.h MDR32F9Qx_config.h MDR32F9Qx_it.c MDR32F9Qx_it.h MDR32F9Qx_lib.h MDR32F9Qx_port.c MDR32F9Qx_port.h
